# Keil uVision project cpp_cortex_M0_library.uvprojx, settings and files
target FRDM-KL05ZJ (6220000::V6.22::ARMCLANG)
  device: MKL05Z32xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.1
  cpu: IRAM(0x1FFFFC00,0x00001000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: cpp_cortex_M0_library +hex
  c flags: Optim=7 OneElfS=1 v6Lang=5 v6LangP=8 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x1ffffc00 size 0x1000
  group src
    ./src/: main.cpp Uart.cpp BoardSupport.cpp CommunicationModuleMCU.cpp
  group inc
    ./inc/: Uart.hpp BoardSupport.hpp CommunicationModuleMCU.hpp CommunicationModuleBase.hpp
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
